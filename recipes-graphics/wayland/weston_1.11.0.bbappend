FILESEXTRAPATHS_prepend := "${THISDIR}/weston:"

SRC_URI += "file://Add-glFinish-to-DRM-backend-to-avoid-tearing.patch \
"
