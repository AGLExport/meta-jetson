
PACKAGE_INSTALL_remove = "psplash"

IMAGE_INSTALL_append = " gstreamer1.0-meta-audio \
                         gstreamer1.0-meta-video \
                         gstreamer1.0-plugins-ugly-mad \
                         "
