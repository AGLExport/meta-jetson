DEPENDS += " libmad "
PACKAGECONFIG += " mad "
