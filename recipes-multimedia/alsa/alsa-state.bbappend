SUMMARY = "ALSA sound configuration for Jetson TK1"

FILESEXTRAPATHS_prepend := ":${THISDIR}/alsa-state:"
